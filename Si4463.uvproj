# Keil uVision project Si4463.uvproj, settings and files
target STM32F3 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Si4463 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group App
    ./Source/: main.c board.h
  group Drv
    ./Source/: startup_stm32f30x.s system_stm32f30x.c drv_system.c drv_gpio.c drv_Si4463.c drv_rf.c
  group Lib
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
